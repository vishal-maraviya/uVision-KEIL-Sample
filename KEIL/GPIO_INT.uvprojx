# Keil uVision project GPIO_INT.uvprojx, settings and files
target GPIO_INT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: GPIO_INT
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\Device\Nuvoton\M480\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../DI/M480_BSP_CMSIS_V3.05.001/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../DI/M480_BSP_CMSIS_V3.05.001/Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c
  group Library
    ../../DI/M480_BSP_CMSIS_V3.05.001/Library/StdDriver/src/: acmp.c bpwm.c can.c ccap.c clk.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c emac.c epwm.c fmc.c gpio.c hsusbd.c i2c.c i2s.c pdma.c qei.c qspi.c retarget.c rtc.c sc.c scuart.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c trng.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
software components: CMSIS:CORE 5.4.0
